# Keil uVision project template.uvprojx, settings and files
target AT32A403AVGT7_template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32A403AVGT7 ArteryTek
  pack: ArteryTek.AT32A403A_DFP.2.0.5
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AT32A403AVGT7,USE_STDPERIPH_DRIVER,AT_START_A403A_V1,ARM_MATH_CM4,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,ARM_MATH_LOOPUNROLL
  c include: ..\Drivers\AT32A403_Driver\inc;..\Drivers\CMSIS\cm4\core_support;..\Drivers\CMSIS\cm4\device_support;..\Core\inc;..\Middlewares\RT-Thread;..\Middlewares\RT-Thread\include;..\BSP;..\APP;..\Middlewares\RT-Thread\components\finsh;..\DSP_Lib\Include;..\Middlewares\RT-Thread\components\cpu_usage;..\Middlewares\CANopen\CanOpenAT32;..\Middlewares\CANopen\CANopenNode
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group MDK-ARM
    ../Drivers/CMSIS/cm4/device_support/startup/mdk/: startup_at32a403a.s
  group APP
    ../APP/: main.c rt_thread.c at32a403a_int.c test_demo.c
  group Core
    ../Core/src/: at32a403a_wk_config.c dma_uart.c
  group RT-Thread
    ../Middlewares/RT-Thread/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
    ../Middlewares/RT-Thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
    ../Middlewares/RT-Thread/: board.c rtconfig.h
  group Finsh
    ../Middlewares/RT-Thread/components/finsh/: cmd.c finsh_port.c msh.c shell.c
  group CPU_Usage
    ../Middlewares/RT-Thread/components/cpu_usage/: cpu_usage.c cpu_usage_cmd.c
  group CANopenNode
    ../Middlewares/CANopen/CANopenNode/: CANopen.c
    ../Middlewares/CANopen/CANopenNode/301/: CO_Emergency.c CO_fifo.c CO_HBconsumer.c CO_NMT_Heartbeat.c CO_Node_Guarding.c CO_ODinterface.c CO_PDO.c CO_SDOclient.c CO_SDOserver.c CO_SYNC.c CO_TIME.c crc16-ccitt.c
    ../Middlewares/CANopen/CANopenNode/303/: CO_LEDs.c
    ../Middlewares/CANopen/CANopenNode/304/: CO_GFC.c CO_SRDO.c
    ../Middlewares/CANopen/CANopenNode/305/: CO_LSSmaster.c CO_LSSslave.c
    ../Middlewares/CANopen/CANopenNode/309/: CO_gateway_ascii.c
    ../Middlewares/CANopen/CANopenNode/extra/: CO_trace.c
    ../Middlewares/CANopen/CANopenNode/storage/: CO_storage.c CO_storageEeprom.c
  group CANopenNode/AT32
    ../Middlewares/CANopen/CanOpenAT32/: CO_app_AT32.c CO_driver_AT32.c CO_storageBlank.c OD.c
  group AT32A403A_Driver
    ../Drivers/AT32A403_Driver/src/: at32a403a_acc.c at32a403a_adc.c at32a403a_bpr.c at32a403a_can.c at32a403a_crc.c at32a403a_crm.c at32a403a_dac.c at32a403a_debug.c at32a403a_dma.c at32a403a_emac.c at32a403a_exint.c at32a403a_flash.c at32a403a_gpio.c at32a403a_i2c.c at32a403a_misc.c at32a403a_pwc.c at32a403a_rtc.c at32a403a_sdio.c at32a403a_spi.c at32a403a_tmr.c at32a403a_usart.c at32a403a_usb.c at32a403a_wdt.c at32a403a_wwdt.c at32a403a_xmc.c
  group DSP_Lib
    ../DSP_Lib/: arm_cortexM4lf_math.lib
  group CMSIS
    ../Drivers/CMSIS/cm4/device_support/: system_at32a403a.c
